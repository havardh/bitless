# IAR project software.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\libs\CMSIS\Include; ..\libs\Device\EnergyMicro\EFM32GG\Include; ..\libs\emlib\inc; ..\libs\kits\common\drivers; ..\libs\kits\common\bsp; ..\libs\kits\EFM32GG_STK3700\config; ..\libs\util\inc; ..\drivers\fpga\inc; ..\types\inc; ..\drivers\prs\inc; ..\drivers\adc\inc; ..\drivers\dac\inc; ..\drivers\mem\inc; ..\drivers\dma\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\libs\CMSIS\Include; ..\libs\Device\EnergyMicro\EFM32GG\Include; ..\libs\emlib\inc; ..\libs\common\drivers; ..\libs\common\bsp; ..\libs\kits\EFM32GG_STK3700\config; ..\libs\util\inc; ..\drivers\fpga\inc; ..\drivers\mem\inc; ..\drivers\dma\inc
  OBJCOPY.OOCOutputFile: software.bin
  ILINK.IlinkOutputFile: software.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32GG990F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../libs/kits/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group CMSIS
    ../libs/Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../libs/Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../libs/kits/common/drivers/: dmactrl.c
  group emlib
    ../libs/emlib/src/: em_adc.c em_cmu.c em_dac.c em_dma.c em_emu.c em_gpio.c em_prs.c em_timer.c
  group Source
    ../drivers/adc/src/: ADCDriver.c
    ../libs/util/src/: Blink.c Delay.c
    ../drivers/dac/src/: DACDriver.c
    ../drivers/dma/src/: DMADriver.c
    ../drivers/fpga/demo/: fpga.c
    ../drivers/fpga/src/: FPGADriver.c
    ../drivers/mem/src/: MEMDriver.c
    ../drivers/dma/demo/: multiple.c
    ../drivers/prs/src/: PRSDriver.c
