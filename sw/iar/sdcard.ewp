# IAR project sdcard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\libs\CMSIS\Include; ..\libs\Device\EnergyMicro\EFM32GG\Include; ..\libs\emlib\inc; ..\libs\fatfs\inc; ..\libs\kits\common\drivers; ..\libs\kits\common\bsp; ..\libs\kits\EFM32GG_DK3750\config; ..\libs\util\inc; ..\drivers\fpga\inc; ..\types\inc; ..\drivers\prs\inc; ..\drivers\int\inc; ..\drivers\adc\inc; ..\drivers\dac\inc; ..\drivers\mem\inc; ..\drivers\sdcard\inc; ..\drivers\dma\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\libs\CMSIS\Include; ..\libs\Device\EnergyMicro\EFM32GG\Include; ..\libs\emlib\inc; ..\libs\fatfs\inc; ..\drivers\int\inc; ..\drivers\sdcard\inc; ..\libs\kits\common\drivers; ..\libs\kits\common\bsp; ..\libs\kits\EFM32GG_DK3750\config; ..\libs\util\inc; ..\drivers\fpga\inc; ..\types\inc; ..\drivers\prs\inc; ..\drivers\adc\inc; ..\drivers\dac\inc; ..\drivers\mem\inc; ..\drivers\dma\inc
  ILINK.IlinkOutputFile: sdcard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../libs/kits/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group CMSIS
    ../libs/Device/ENERGYMICRO/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../libs/Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group Drivers
    ../libs/kits/common/drivers/: dmactrl.c microsd.c
  group emlib
    ../libs/emlib/src/: em_adc.c em_assert.c em_cmu.c em_dac.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_prs.c em_system.c em_timer.c em_usart.c
  group fatfs
    ../libs/fatfs/src/: diskio.c ff.c
  group Source
    ../drivers/adc/src/: ADCDriver.c
    ../libs/util/src/: CircularBuffer.c fatfs_file.c sample_conversion.c wav.c
    ../drivers/sdcard/demo/: copy-file.c
    ../drivers/dac/src/: DACDriver.c
    ../drivers/dma/src/: DMADriver.c
    ../drivers/fpga/src/: FPGADriver.c
    ../drivers/int/src/: INTDriver.c
    ../drivers/mem/src/: MEMDriver.c
    ../drivers/prs/src/: PRSDriver.c
    ../drivers/sdcard/src/: SDDriver.c
